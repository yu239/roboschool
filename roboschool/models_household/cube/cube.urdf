Commit message: add doc

File: roboschool/models_household/cube/cube.urdf (robot description, URDF)
Before this commit: robot ball, 1 links, 0 joints
Links:
- link body: mass 10.0 -> 1.0
